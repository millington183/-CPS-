# Keil uVision project PIONEER.uvprojx, settings and files
target PIONEER (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PIONEER +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\sys;..\HARDWARE\delay;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\uCOS-II\uC-CPU\ARM-Cortex-M4;..\uCOS-II\uC-LIB\ARM-Cortex-M4;..\uCOS-II\Ports\ARM-Cortex-M4;..\uCOS-II\Source;..\Config;..\HARDWARE\Uart;..\OSconfig;..\Source;..\HARDWARE\Timer;..\HARDWARE\RS485;..\HARDWARE\IO;..\HARDWARE\I2C;..\HARDWARE\EEPROM;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\STMFLASH;..\HARDWARE;..\HARDWARE\IWDG;..\HARDWARE\Exti;..\HARDWARE\RTC;..\HARDWARE\Print;..\HARDWARE\HX711;..\HARDWARE\Display;..\HARDWARE\LED;..\Source\APP_Init;..\Source\IRQHandler;..\Source\NB-IoT;..\Source\TaskDisplay;..\Source\TaskNB;..\Source\UserVars;..\Source\TsakScan;..\Source\TaskPressure;..\Source\TaskPLC;..\Source\TaskNumber;..\Source\TaskEnvironment;..\HARDWARE\ADC;..\Source\TaskKey;..\HARDWARE\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c
  group Config
    ../Config/: const.h PIONEER_Config.h
  group Source
    ../Source/: main.c
    ../Source/IRQHandler/: IRQHandler.c
    ../Source/APP_Init/: APP_Init.c
    ../Source/UserVars/: UserVars.c
    ../Source/NB-IoT/: NB_IoT.c
    ../Source/TaskDisplay/: TaskDisplay.c
    ../Source/TaskEnvironment/: TaskEnvironment.c
    ../Source/TaskNB/: TaskNB.c
    ../Source/TaskNumber/: TsakNumber.c
    ../Source/TaskPLC/: TaskPLC.c
    ../Source/TaskPressure/: TaskPressure.c
    ../Source/TsakScan/: TaskScan.c
    ../Source/TaskProcessing/: TaskProcessing.c
    ../Source/TaskQualified/: TaskQualified.c
    ../Source/TaskFlash/: TaskFlash.c
  group OSconfig
    ../OSconfig/: app_cfg.h os_cfg.h OSHook.c OSVars.c
  group HARDWARE
    ../HARDWARE/: STM32F4_Head.h
    ../HARDWARE/Uart/: Uart.c
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/I2C/: I2C.c
    ../HARDWARE/EEPROM/: EEPROM.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/Exti/: Exti.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/Display/: cmd_queue.c hmi_driver.c hmi_user_uart.c ulitity.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/HX711/: HX711.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_adc.c
  group uCOS-II
    ../uCOS-II/: ucos-ii.c
    ../uCOS-II/Ports/ARM-Cortex-M4/: os_cpu_a.asm
    ../uCOS-II/uC-CPU/ARM-Cortex-M4/: cpu_a.asm
    ../uCOS-II/uC-LIB/ARM-Cortex-M4/: lib_mem_a.asm
